/**********************************************************************************************************************
 * Includes
 *********************************************************************************************************************/
#include "cmsis_os.h"
#include "heap_api.h"
/**********************************************************************************************************************
 * Private definitions and macros
 *********************************************************************************************************************/
#define CB_MEM_DEFAULT NULL
#define CB_SIZE_DEFAULT 0
/**********************************************************************************************************************
 * Private typedef
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Private constants
 *********************************************************************************************************************/
const static osMutexAttr_t g_static_uart_mutex_attr = {
    .name = "Heap Api Mutex",
    .attr_bits = osMutexRecursive,
    .cb_mem = CB_MEM_DEFAULT,
    .cb_size = CB_SIZE_DEFAULT
};
/**********************************************************************************************************************
 * Private variables
 *********************************************************************************************************************/
static osMutexId_t heap_mutex = NULL;
/**********************************************************************************************************************
 * Exported variables and references
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Prototypes of private functions
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Definitions of private functions
 *********************************************************************************************************************/

/**********************************************************************************************************************
 * Definitions of exported functions
 *********************************************************************************************************************/
bool HEAP_API_Init (void) {
    if (heap_mutex != NULL) {
        return false;
    }

    heap_mutex = osMutexNew(&g_static_uart_mutex_attr);
    if (heap_mutex == NULL) {
        return false;
    }

    return true;
}

void *HEAP_API_Alloc (bool is_calloc, size_t number, size_t size) {
    if ((number <= 0) || (size <= 0)) {
        return NULL;
    }

    if (heap_mutex == NULL) {
        return NULL;
    }

    if (osMutexAcquire(heap_mutex, osWaitForever) != osOK) {
        return NULL;
    }

    void *ptr = is_calloc ? calloc(number, size) : malloc(number * size);

    if (osMutexRelease(heap_mutex) != osOK){
        return NULL;
    }

    return ptr;
}

void HEAP_API_Free (void *memory_pointer) {
    if (memory_pointer == NULL) {
        return;
    }

    if (heap_mutex == NULL) {
        return;
    }

    if (osMutexAcquire(heap_mutex, osWaitForever) != osOK) {
        return;
    }

    free(memory_pointer);

    if (osMutexRelease(heap_mutex) != osOK) {
        return;
    }
}
